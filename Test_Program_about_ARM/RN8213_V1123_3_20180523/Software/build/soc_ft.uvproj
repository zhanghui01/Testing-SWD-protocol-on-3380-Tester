# Keil uVision project soc_ft.uvproj, settings and files
target SIZE1 (ARM-ADS)
  device: LPC1759 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: soc_ft
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIZE1
  c include: ..\driver;..\..\testcase
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../driver/: ft_main.c Serial.c swd_atf.c swd_drv.c system_LPC17xx.c startup_LPC17xx.s board.c test_all.c Voltage.c LCD_Pump.c adc.c spi.c spline.c ra0_routine.c timer.c ads_acquire.c temper_process.c EMU.c ldo18_trim.c rcl_trim.c sar.c Retarget.c
target SIZE2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1759 NXP (founded by Philips)
  cpu: as above
  output: soc_ft
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIZE2
  c include: ..\driver;..\..\testcase
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
