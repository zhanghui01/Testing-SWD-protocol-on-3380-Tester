# Keil uVision project MIP_FT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MIP_FT
  AfterMake: fromelf --bin -o ../MIP_FT.bin MIP_FT.axf
  c flags: Optim=1
  c include: ..\src;..\sysfile
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1ff0
  memory RVCT9: RAM 0x2000 size 0x800
  group src
    ../src/: FLASH_FT.c MIP_FT.c ROM_FT.c flash_driver.c EEPROM_FT.c eeprom_driver.c
  group sysfile
    ../sysfile/: common.c Retarget.c serial.c system_RN821x.c startup_RN821x.s rn821x_nvm.lib rn821x_sysctrl.lib
