# Keil uVision project AES_QC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RN8213 Renergy
  cpu: IRAM(0x10000000-0x100027ff) IROM(0-0x2ffff) CLOCK(4000000) CPUTYPE("Cortex-M0")
  output: AES_FT
  AfterMake: fromelf --bin -o ../AES_FT.bin AES_FT.axf
  c flags: Optim=1
  c include: ..\src;..\src\common;..\src\common\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1ff0
  memory RVCT9: RAM 0x2000 size 0x800
  group Source Group 1
    ../src/common/: clk_calc.c common.c
    ../src/common/lib/: rn821x_sysctrl.lib
    ../src/: system_RN821x.c startup_RA9103.s main.c
