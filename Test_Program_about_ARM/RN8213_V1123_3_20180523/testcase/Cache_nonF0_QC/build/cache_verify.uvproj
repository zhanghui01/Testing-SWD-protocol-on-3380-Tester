# Keil uVision project cache_verify.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RN8219 Renergy
  cpu: IRAM(0x10000000-0x100027ff) IROM(0-0x2ffff) CLOCK(4000000) CPUTYPE("Cortex-M0")
  output: Cache_nonF0_QC
  AfterMake: fromelf --bin Cache_nonF0_QC.axf -o ../Cache_nonF0_QC.bin
  c flags: Optim=1
  c define: RA9103C
  c include: ..\common_files;..\CMSIS\RA9103;..\common_files\lib;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x1000 size 0x1000
  group CMSIS
    ../CMSIS/RA9103/: system_RA9103.c
    ../CMSIS/RA9103/startup/arm/: startup_RA9103.s
  group MISC
    ../common_files/: flash_driver.c
  group SRC
    ../src/: cache_verify.c
