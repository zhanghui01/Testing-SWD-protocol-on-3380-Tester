# Keil uVision project ALL_REG_WR_QC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RA9103D0 Renergy
  cpu: IRAM(0x10000000-0x10001fff) IROM(0-0x1ffff) CLOCK(3686400) CPUTYPE("Cortex-M0")
  output: ALL_REG_WR_QC
  AfterMake: fromelf --bin ALL_REG_WR_QC.axf -o ../ALL_REG_WR_QC.bin
  c flags: Optim=1
  c include: ..\src;..\src\common;..\src\common\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x800
  group Source Group 1
    ../src/common/: common.c clk_calc.c Retarget.c serial.c
    ../src/: startup_RA9103.s system_RN821x.c ALL_REG_WR_QC.c
    ../src/common/lib/: rn821x_sysctrl.lib
