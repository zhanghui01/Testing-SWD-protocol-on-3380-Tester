# Keil uVision project SocLowPwr_sys.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Soc_DISLowPwr_sys
  AfterMake: fromelf --bin -o ..\Soc_DISLowPwr_sys.bin Soc_DISLowPwr_sys.axf
  c flags: Optim=1
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x1700
  group Source Group 1
    ../src/: common.c nvm.c Retarget.c serial.c SocLowPwr_sys.c sysctrl.c system_RN821x.c sysupdate.c startup_RA9103.s
