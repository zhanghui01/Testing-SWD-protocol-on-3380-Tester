# Keil uVision project RTC_QC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RN8215 Renergy
  cpu: IRAM(0x10000000-0x100037ff) IROM(0-0x2ffff) CLOCK(3686400) CPUTYPE("Cortex-M0")
  output: ZPLL_1Hz_FT
  AfterMake: fromelf --bin ZPLL_1Hz_FT.axf -o ../ZPLL_1Hz_FT.bin
  c flags: Optim=1
  c include: ..\src;..\src\common;..\src\common\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x1700
  group Source Group 1
    ../src/common/: common.c Retarget.c serial.c clk_calc.c
    ../src/common/lib/: rn821x_sysctrl.lib
    ../src/: RTC_QC.c startup_RA9103.s system_RN821x.c
