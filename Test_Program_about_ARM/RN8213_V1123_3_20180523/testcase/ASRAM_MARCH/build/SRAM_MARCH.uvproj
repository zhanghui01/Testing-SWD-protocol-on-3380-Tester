# Keil uVision project SRAM_MARCH.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RA9103D0 Renergy
  cpu: IRAM(0x10000000-0x10001fff) IROM(0-0x1ffff) CLOCK(3686400) CPUTYPE("Cortex-M0")
  output: SRAM_MARCH +hex
  AfterMake: fromelf --bin SRAM_MARCH.axf -o ../SRAM_MARCH.bin
  c flags: Optim=1
  c include: ..\src;..\src\cmsis\CM0\DeviceSupport\Renergy\RN8215
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x7f0
  group New Group
    ../src/cmsis/CM0/DeviceSupport/Renergy/RN8215/: system_RN8215.c
    ../src/cmsis/CM0/DeviceSupport/Renergy/RN8215/startup/arm/: startup_RN8215.s
