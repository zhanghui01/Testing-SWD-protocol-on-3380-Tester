# Keil uVision project GPIO_FT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: GPIO_FT
  AfterMake: fromelf --bin -o ../GPIO_FT.bin GPIO_FT.axf
  c flags: Optim=1
  c include: ..\src;..\sysfile
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x1700
  group Source Group 1
    ../src/: GPIO_FT.c
    ../sysfile/: common.c Retarget.c serial.c system_RN821x.c startup_RN821x.s rn821x_nvm.lib rn821x_sysctrl.lib
