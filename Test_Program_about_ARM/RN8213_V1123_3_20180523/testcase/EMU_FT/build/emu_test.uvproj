# Keil uVision project emu_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: rn8213 Renergy
  cpu: IRAM(0x10000000-0x100027ff) IROM(0-0x2ffff) CLOCK(4000000) CPUTYPE("Cortex-M0")
  output: EMU_QC
  AfterMake: fromelf --bin -o ../EMU_FT.bin EMU_QC.axf
  c flags: Optim=1
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x1700
  group source
    ../src/: common.c common.h nvm.c nvm.h Retarget.c RN821x.h serial.c startup_RA9103.s sysctrl.c sysctrl.h system_RN821x.c system_RN821x.h EMU_QC.c
